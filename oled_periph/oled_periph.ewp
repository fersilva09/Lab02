# IAR project oled_periph.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1343 NXP LPC1343
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG
  ICCARM.CCIncludePath2: ..; ..\Device\NXP\LPC13xx\Include\; ..\Drivers\include; ..\Lib_EaBaseBoard\inc; ..\Lib_MCU\inc; ..\Lib_CMSISv1p30_LPC13xx\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: oled_periph.out
  ILINK.IlinkIcfFile: ..\linker\ldscript_irom_iar.ld
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../Lib_EaBaseBoard/Debug/Exe/: Lib_EaBaseBoard.a
    ../Lib_MCU/Debug/Exe/: Lib_MCU.a
    src/: main.c
    ./: readme.txt
    ../Device/NXP/LPC13xx/Source/IAR/: startup_LPC13xx.s
    ../Device/NXP/LPC13xx/Source/: system_LPC13xx.c
